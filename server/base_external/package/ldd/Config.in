## server/base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Building and installing the misc-modules and scull using LDD package
```
